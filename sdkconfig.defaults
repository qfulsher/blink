## sdkconfig.defaults
```kconfig
CONFIG_BLINK_LED_GPIO=y
CONFIG_BLINK_GPIO=8
CONFIG_PARTITION_TABLE_SINGLE_APP_LARGE=y
```
